<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Backup of demoLQ_KV58F24.ewp</path>
    </project>
    <batchBuild />
</workspace>
